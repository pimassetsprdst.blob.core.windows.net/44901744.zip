Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2023-04-03T14:59:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 03 14:59:38 2023 * Host: LCULICA-RO-LE * Database: C:\Users\lculica\AppData\Local\Temp\909f91d7-306a-4862-98e4-5442bcd47b57\4cc9ccec-2c54-40cc-a894-b53b4ea8bd5c\ifc * Database version: 5507 * Database creation date: Mon Apr 03 14:59:37 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Apr 03 14:59:38 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 03 14:59:38 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcDistributionPort (12)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcJunctionBox: PGST B2CA E5 BW, E_Ceiling Junction Box_MEPcontent_ABB_PGST BW_NL-NL:PGST B2CA E5 BW:1391323
In: V00
Type - Material: Color RGB 230-000-071, Color RGB 255-255-255, Color RGB 070-070-070
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 160 mm; Diameter: 76 mm; Height: 77 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 180 deg; Rotation W-Axis Correction: 0 deg; Width: 440 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Identity Data - Article Type: PGST B2CA E5 BW; Base Family Version: 22.13; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Doos voor montage in wand/plafond Stekerbare centraaldoos brandwerend Brandwerende centraaldoos voor holle plafonds, voorbedraad en voorzien van stekers, 1 x GST18/3 Male Zwart, tbv Gipsplaat dikte 25 mm; EMCS Version: 4.0; ETIM Article Class: EC002601; Family Version: 22.13; GLN: 8712507100009; Manufacturer: ABB; Manufacturer URL: http://www.abbconnect.nl/Details/Index.aspx/1SPA007182F0705?languageCode=nl&country=nl; MEPcontent Class: CEILING_JUNCTION_BOX; Model: PGST B2CA E5 BW; OmniClass Number: 23.80.30.14.24; OmniClass Title: Junction Boxes; Revit Version: 2020; Type Name: PGST B2CA E5 BW; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Connector 1 Color: Color RGB 070-070-070; Connector 2 Color: Color RGB 070-070-070; Connector 3 Color: Color RGB 070-070-070; Connector 4 Color: Color RGB 070-070-070; Connector 5 Color: Color RGB 070-070-070; Connector 6 Color: Color RGB 070-070-070; Red: Color RGB 230-000-071; White: Color RGB 255-226-181
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Connector 1 Female Visibility: no; Connector 1 Male Visibility: no; Connector 2 Female Visibility: no; Connector 2 Male Visibility: yes; Connector 3 Female Visibility: no; Connector 3 Male Visibility: no; Connector 4 Female Visibility: no; Connector 4 Male Visibility: no; Connector 5 Female Visibility: no; Connector 5 Male Visibility: no; Connector 6 Female Visibility: no; Connector 6 Male Visibility: no; Endcap Offset: 17.8 mm; Family Name: E_Ceiling Junction Box_MEPcontent_ABB_PGST BW_NL-NL; Offset: 15 mm
Type - Text - Article Description: Doos voor montage in wand/plafond Stekerbare centraaldoos brandwerend Brandwerende centraaldoos voor holle plafonds, voorbedraad en voorzien van stekers, 1 x GST18/3 Male Zwart, tbv Gipsplaat dikte 25 mm; Connector Description 2: 3P male; GTIN: 8712507453419; Manufacturer Art. No.: 1SPA007182F0705; Product Line: ABB
Type - Pset_EnvironmentalImpactIndicators - Reference: PGST B2CA E5 BW
Type - Pset_JunctionBoxTypeCommon - Reference: PGST B2CA E5 BW; IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Conduit Connector 16mm 1: yes; Conduit Connector 16mm 2: yes; Conduit Connector 16mm 3: yes; Conduit Connector 16mm 4: yes; Conduit Connector 19mm 1: no; Conduit Connector 19mm 2: no; Conduit Connector 19mm 3: no; Conduit Connector 19mm 4: no; Conduit Connector 20mm 1: no; Conduit Connector 20mm 2: no; Conduit Connector 20mm 3: no; Conduit Connector 20mm 4: no; Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.0659929 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000625897 m3
Identity Data - Function Code: E6000; Mark: 6
Other - Conduit Diameter 1: 16 mm; Conduit Diameter 2: 16 mm; Conduit Diameter 3: 16 mm; Conduit Diameter 4: 16 mm; Family: E_Ceiling Junction Box_MEPcontent_ABB_PGST BW_NL-NL: PGST B2CA E5 BW; Family and Type: E_Ceiling Junction Box_MEPcontent_ABB_PGST BW_NL-NL: PGST B2CA E5 BW; Type: E_Ceiling Junction Box_MEPcontent_ABB_PGST BW_NL-NL: PGST B2CA E5 BW; Type Id: E_Ceiling Junction Box_MEPcontent_ABB_PGST BW_NL-NL: PGST B2CA E5 BW
Phasing - Phase Created: 3. Nieuwbouw
Visibility - CD/RVK Cover Visible: no; CD_RVK ILD Airtight Insert Visible: no; CHP 60 K Visible 1: no; CHP 60 K Visible 2: no
